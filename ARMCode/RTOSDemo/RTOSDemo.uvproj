# Keil uVision project RTOSDemo.uvproj, settings and files
target WebServerELF (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group MainSource
    ./MainFiles/: main.c LCDtask.c myTimers.c conductor.c conductor.h i2c_ARM.c i2c_ARM.h irControl.c irControl.h LCDtask.h motorControl.c motorControl.h myDefs.h myTimers.h myTypes.h navigation.c navigation.h power.c power.h speedLimit.c speedLimit.h webServer.c webServer.h
    ../vtCode/: vtUtilities.c
    ../FreeRTOS/Demo/CORTEX_LPC1768_GCC_Rowley/: ParTest.c
  group System Files
    ../SystemFiles/: syscalls.c system_LPC17xx.c startup_LPC17xx.s
  group LPCUSB
    ../LPCUSB/: USB_CDC.c
    ../FreeRTOS/Demo/CORTEX_LPC1768_GCC_Rowley/LPCUSB/: usbcontrol.c usbhw_lpc.c usbinit.c usbstdreq.c
  group Common Demo Tasks
    ../FreeRTOS/Demo/Common/Minimal/: BlockQ.c blocktim.c flash.c GenQTest.c integer.c PollQ.c QPeek.c recmutex.c semtest.c
  group webserver
    ../FreeRTOS/Demo/CORTEX_LPC1768_GCC_Rowley/webserver/: emac.c httpd.c httpd-cgi.c httpd-fs.c http-strings.c uIP_Task.c
    ../FreeRTOS/Demo/Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip_arp.c uip.c
  group LCD
    ../vtCode/vtLCD/: vtSSP.c GLCD_SPI_LPC1700.c
  group Drivers
    ../NXPDrivers/source/: lpc17xx_clkpwr.c lpc17xx_i2c.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_ssp.c
  group I2C
    ../vtCode/vtI2C/: vtI2C.c
